# IAR project Backup of TIM_TimeBase.ewp, settings and files
configuration TIM_TimeBase (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ..\; ..\Libraries\CMSIS\Include; ..\Libraries\CMSIS\ST\STM32F0xx\Include; ..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\Utilities\STM32F0-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIM_TimeBase.srec
  ILINK.IlinkOutputFile: TIM_TimeBase.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group EWARM/FAT_Fs
    ../: ff.c mmc_32f0.c
  group STM32F0xx_StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dac.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group User
    ../: config.c delay.c errors.c fileexplorer.c main.c stm32f0_fonts.c stm32f0_ili9341.c stm32f0xx_it.c string.c system_stm32f0xx.c timeout.c wav.c
